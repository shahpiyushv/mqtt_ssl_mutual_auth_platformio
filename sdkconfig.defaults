## sdkconfig.defaults
```kconfig
#Temporary Fix for ESP IDF issue
CONFIG_MBEDTLS_CERTIFICATE_BUNDLE=
CONFIG_EXAMPLE_WIFI_SSID="myssid"
CONFIG_EXAMPLE_WIFI_PASSWORD="mypassword"
```
